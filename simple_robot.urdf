Commit message: Added collision and inertial tags for caster wheel

File: simple_robot.urdf (robot description, URDF)
Before this commit: robot my_robot, 6 links, 5 joints
Links:
- link caster_wheel: mass None -> 0.25; geometry collision sphere radius=0.05; visual sphere radius=0.05
